# Keil uVision project GD32F450_Template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F403VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.1.0.4
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F450_Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\third_lib\CMIS;..\third_lib\FreeRtos\include;..\third_lib\peripheral_lib\Include;..\third_lib\FreeRtos;..\third_lib\FreeRtos\portable\RVDS;..\app;..\third_lib\FreeRtos\portable\RVDS\ARM_CM4F;.\RTE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../app/: gd32f4xx_it.c gd32f4xx_it.h main.c gd32f403_libopt.h
  group freertos_port
    ../third_lib/FreeRtos/portable/MemMang/: heap_4.c
    ../third_lib/FreeRtos/portable/RVDS/ARM_CM4F/: port.c
  group freerrtos
    ../third_lib/FreeRtos/: croutine.c event_groups.c FreeRTOSConfig.h list.c queue.c readme.txt tasks.c timers.c
  group cmis
    ../third_lib/CMIS/: system_gd32f403.c gd32f403.h startup_gd32f403.s
  group common
    ../common/: soft_timer.c
  group peripheral_lib
    ../third_lib/peripheral_lib/Source/: gd32f403_adc.c gd32f403_bkp.c gd32f403_can.c gd32f403_crc.c gd32f403_ctc.c gd32f403_dac.c gd32f403_dbg.c gd32f403_dma.c gd32f403_exmc.c gd32f403_exti.c gd32f403_fmc.c gd32f403_fwdgt.c gd32f403_gpio.c gd32f403_i2c.c gd32f403_misc.c gd32f403_pmu.c gd32f403_rcu.c gd32f403_rtc.c gd32f403_sdio.c gd32f403_spi.c gd32f403_timer.c gd32f403_usart.c gd32f403_wwdgt.c
